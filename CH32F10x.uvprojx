# Keil uVision project CH32F10x.uvprojx, settings and files
target CH32F10x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CH32F103R8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F10x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --no-multibyte-chars
  c include: .\core;.\Debug;.\peripheral\inc;.\Startup;.\peripheral\src;.\User\ADC;.\User\Src;.\User\Inc;.\User\Temp;.\User\Display
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./Startup/: startup_ch32f10x.s
  group core
    ./core/: core_cm3.c
  group debug
    ./Debug/: debug.c
  group peripheral
    ./peripheral/src/: ch32f10x_adc.c ch32f10x_bkp.c ch32f10x_can.c ch32f10x_crc.c ch32f10x_dac.c ch32f10x_dbgmcu.c ch32f10x_dma.c ch32f10x_exti.c ch32f10x_flash.c ch32f10x_gpio.c ch32f10x_i2c.c ch32f10x_iwdg.c ch32f10x_misc.c ch32f10x_pwr.c ch32f10x_rcc.c ch32f10x_rtc.c ch32f10x_spi.c ch32f10x_tim.c ch32f10x_usart.c ch32f10x_usb.c ch32f10x_wwdg.c
  group user/ADC
    ./User/ADC/: Filter.c Filter.h HCT6521.c HCT6521.h Weight.c Weight.h Calibration.c Calibration.h FilterTest.c FilterTest.h
  group user/Display
    ./User/Display/: SM16028E.c SM16028E.h Led.c Led.h
  group user/inc
    ./User/Inc/: ch32f10x_conf.h ch32f10x_it.h system_ch32f10x.h GameLogic.h Key.h MyRTC.h Project_Config.h PunchDetect.h Timer.h MyFlash.h
  group user/src
    ./User/Src/: ch32f10x_it.c main.c system_ch32f10x.c GameLogic.c Key.c MyRTC.c PunchDetect.c Timer.c MyFlash.c
